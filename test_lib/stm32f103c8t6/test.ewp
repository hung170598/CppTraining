# IAR project test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: G:\Librares\Embedded_C99\Microcontroller\stm32f10x\test_lib\stm32f103c8t6\include; G:\Librares\Embedded_C99\Microcontroller\stm32f10x\driver\include; G:\Librares\Embedded_C99\Microcontroller\stm32f10x\test_lib\0_common\include; G:\Librares\Embedded_C99\Microcontroller\stm32f10x\test_lib\1_application
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: test.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application
    ../1_application/: led.c
    source/: main.c
  group Driver
    ../../driver/: gpio.c rcc.c
  group Include
    ../0_common/include/: define.h
    ../1_application/: led.h
